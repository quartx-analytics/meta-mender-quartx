# Bash is a better shell to work with
RDEPENDS_${PN}_append = " bash"

MENDER_CONNECT_USER = "root"
MENDER_CONNECT_SHELL = "/bin/bash"
