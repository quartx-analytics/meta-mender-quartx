# Install Mender add-ons
RDEPENDS_${PN}_append_mender-image = " mender-connect"
